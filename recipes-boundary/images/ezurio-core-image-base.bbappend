IMAGE_INSTALL:append = " \
    htop \
    psplash \
    chromium-ozone-wayland \
    weston \
"

