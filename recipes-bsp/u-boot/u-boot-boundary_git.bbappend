FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-boundary:"

SRC_URI += " \
    file://extra_env.cfg \
    file://fastboot_uuu.cfg \
"

