SRC_URI = " \
    git://github.com/containers/skopeo;branch=release-1.15;protocol=https;destsuffix=git/src/github.com/containers/skopeo \
    file://0001-makefile-add-GOBUILDFLAGS-to-go-build-call.patch \
"

SRCREV = "99e3c44865d4200bb93f38365622ef1e857c3a61"
PV = "v1.15.0+git"

